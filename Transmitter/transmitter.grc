options:
  parameters:
    generate_options: qt_gui
    id: waterfall
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '915_000_000'
  states: {}
- name: delta_freq
  id: variable
  parameters:
    value: delta_freq_slider
  states: {}
- name: delta_freq_slider
  id: variable_qtgui_range
  parameters:
    label: Frequency Delta
    rangeType: int
    start: '-10_000'
    step: '100'
    stop: '10_000'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32_000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: delta_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
